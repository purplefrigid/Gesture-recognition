# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\ANO;..\HARDWARE\FDC2X14;..\HARDWARE\HC05;..\HARDWARE\IIC;..\HARDWARE\INIT;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\TASK;..\HARDWARE\TIMER;..\HARDWARE\USART2;..\HARDWARE\kalman;..\HARDWARE\GESTURE;..\HARDWARE\LCD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group LCD
    ../HARDWARE/LCD/: LCDInfo.c LCDInfo.h lcd1.c
  group ANO
    ../HARDWARE/ANO/: Ano.c
  group INIT
    ../HARDWARE/INIT/: init.c
  group TASK
    ../HARDWARE/TASK/: task.c
  group KEY
    ../HARDWARE/KEY/: key1.c
  group HC05
    ../HARDWARE/HC05/: hc05.c
  group TIMER
    ../HARDWARE/TIMER/: timer.c
  group LED
    ../HARDWARE/LED/: led.c
  group USART2
    ../HARDWARE/USART2/: usart2.c
  group FDC2214
    ../HARDWARE/FDC2X14/: FDC2X14.c
  group IIC
    ../HARDWARE/IIC/: myiic.c
  group GESTURE
    ../HARDWARE/GESTURE/: gesture.c
